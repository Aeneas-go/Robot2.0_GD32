# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_START (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_START
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\Firmware\GD32E23x_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32E23x\Include;..\User;..\Hardware;..\Hardware\usart;..\Robot;..\Frame;..\Action;..\Module;..\Module\EMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Doc
    ../Doc/: readme.txt
  group Action
    ../Action/: Action.c Action.h common.h
  group Hardware
    ../Hardware/usart/: bsp_usart.c bsp_usart.h
    ../Hardware/: bluetooch.c bluetooth.h OLED.c OLED.h OLED_Font.h mymath.c mymath.h
  group Frame
    ../Frame/: Frame.c Frame.h
  group Robot
    ../Robot/: RobotServoController.c RobotServoController.h
  group Module
    ../Module/: bsp_ultrasonic.c bsp_ultrasonic.h bsp_mpu6050.c bsp_mpu6050.h
  group EMPL
    ../Module/EMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group User
    ../User/: gd32e23x_it.c main.c systick.c
software components: CMSIS:CORE 5.0.2
